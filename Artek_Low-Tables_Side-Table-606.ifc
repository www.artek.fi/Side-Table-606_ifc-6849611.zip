Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2022-09-25T21:14:50
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20170223_1515(x64) - Exporter 18.4.0.0 - Alternate UI 18.4.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Sun Sep 25 21:14:50 2022 * Host: DESKTOP-4UM54TC * Database: C:\Users\Vlad\AppData\Local\Temp\{5F992ED6-98B3-426E-A7C3-1418AA390066}\ifc * Database version: 5507 * Database creation date: Sun Sep 25 21:14:49 2022 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Sun Sep 25 21:14:50 2022 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Sun Sep 25 21:14:50 2022 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Constraints(Type) - Elevation Base: Project Base Point
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head

# IfcFurnishingElement: Side Table 606, Artek_Low-Tables_Side-Table-606:Side Table 606:300331
In: Level 1
Type - Material: Stainless Steel, Natural Birch, lacquered
Type - General - Author: BIMStone; BIMObjectName: Artek_Low-Tables_Side-Table-606; ManufacturerName: Artek; ManufacturerURL: https://www.artek.fi/; NBSDescription: Domestic chairs; NBSReference: 45-35-20/365; ProductInformation: Composed of a tubular steel frame and a birch plywood top, Side Table 606 can be pulled tight to armchairs, sofas, and beds thanks to its three-quarter-moon base.; Revision: n/a; Uniclass2: Pr_40_50_21_14; Uniclass2015Description: Coffee tables; Uniclass2015Reference: Pr_40_50_21_14; Version: 1; VersionDate: 23/09/2022
Type - Identity Data - Cost: 0; Description: Composed of a tubular steel frame and a birch plywood top, Side Table 606 can be pulled tight to armchairs, sofas, and beds thanks to its three-quarter-moon base.; Designer: Alvar Aalto; Manufacturer: Artek; Model: Side Table 606; OmniClass Number: 23.40.20.14.14.11; OmniClass Title: Chairs; Type Name: Side Table 606; URL: https://www.artek.fi/en/products/side-table-606
Type - Materials and Finishes - TableMainMaterial: Natural Birch, lacquered
Type - Other - AccessibilityPerformance: n/a; AssetType: Movable; Brand: Artek; Category: Low Tables; CodePerformance: n/a; Color: Wooden; Constituents: n/a; DurationUnit: Years; ExpectedLife: n/a; Family Name: Artek_Low-Tables_Side-Table-606; Features: n/a; Finish: n/a; Grade: n/a; Material: Wood; ModelNumber: n/a; ModelReference: n/a; Name: Side-Table-606; ReplacementCost: n/a; Shape: Sculptured; Size: 500x400x450 mm; SustainabilityPerformance: n/a; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: n/a; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Constraints - Host: Level : Level 1; Level: Level: Level 1; Moves With Nearby Elements: no; Offset: 0 mm
Dimensions - Area: 0.658482 m2; Volume: 0.102136 m3
Materials and Finishes - TableSecondaryMaterial: Stainless Steel
Other - AssetIdentifier: n/a; Barcode: n/a; Category: Furniture; Family: Artek_Low-Tables_Side-Table-606: Side Table 606; Family and Type: Artek_Low-Tables_Side-Table-606: Side Table 606; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: Artek_Low-Tables_Side-Table-606: Side Table 606; Type Id: Artek_Low-Tables_Side-Table-606: Side Table 606; WarrantyStartDate: n/a
Phasing - Phase Created: Phase 1
